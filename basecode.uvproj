# Keil uVision project basecode.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51xB9xE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: basecode
  c flags: Optimize=8 SizeSpeed=1
  group Startup
    ./: MS51_STARTUP.A51
  group drivers
    ../../Downloads/en-us--MS51_Series_BSP_Keil_V1.00.005 (3)/MS51_Series_BSP_Keil_V1.00.005/MS51FB9AE_MS51XB9AE_MS51XB9BE/Library/StdDriver/src/: common.c
  group src
    ./: app.c
